# dmidecode 3.x already uses CC ?= / CFLAGS ?= / CFLAGS +=, so the old
# use-oe-vars.patch (forced CC=gcc removal) no longer applies and is unused.
