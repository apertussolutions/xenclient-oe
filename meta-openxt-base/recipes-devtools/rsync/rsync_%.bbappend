PACKAGECONFIG:append = "attr"
