# When meta-openxt-ui is in BBLAYERS, add display/UI packages to dom0.
IMAGE_INSTALL:append = " packagegroup-openxt-dom0-display"
